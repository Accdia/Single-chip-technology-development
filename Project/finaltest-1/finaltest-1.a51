ORG 0000H
LJMP MAINT
ORG 0023H
LJMP INTSE1
ORG 0100H
MAINT: MOV SCON,#40H
MOV TMOD,#20H
MOV PCON,#0
MOV TH1,#72H
MOV TL1,#72H
SETB TR1
SETB EA
SETB ES
MOV DPTR,#ADDRT
MOV R0,#00H

MOVC A,@A+DPTR
MOV SBUF,A
CLR A
SJMP $
ADDRT:DB 30H,22H,12H,11H,0AAH,0F0H,99H,0DH,56H,00H,13H,65H,0EH,0FFH,73H,0BBH
ORG 0300H
INTSE1:CLR TI
CJNE R0,#10H,LOOP

CLR ES
SJMP ENDT
LOOP:INC R0
INC DPTR
MOVC A,@A+DPTR
MOV SBUF,A
CLR A
ENDT:RETI
END