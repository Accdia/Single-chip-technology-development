ORG 0000H
START:
MOV DPTR,#TAB
MOV R3,#08H
MOV R0,#00H
MOV R1,#0FEH
NEXT: 
MOV A,R1
MOV P1,A
RL A
MOV R1,A
MOV A,R0
MOVC A,@A+DPTR
MOV P0,A
LCALL DELAY
INC R0
DJNZ R3,NEXT
SJMP START
DELAY: 
MOV R6,#200
DELAY1:
MOV R7,#248
DJNZ R7,$
DJNZ R6,DELAY1
RET
TAB: DB  3FH,06H,5BH,4FH,66H,6DH,7DH,07H
END