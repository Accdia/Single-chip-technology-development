BYTES EQU 2		
ORG 0000H
LJMP MAIN
ORG 0100H
MAIN:
MOV 31H,#2EH
MOV 30H,#0A3H
MOV 41H,#57H
MOV 40H,#1DH
MOV R0,#30H		
MOV R1,#50H		
LCALL BINBCD	
MOV R0,#40H		
MOV R1,#60H		
LCALL BINBCD
MOV R0,#50H		
MOV R1,#60H		
MOV R2,#3
LCALL ADDP	
LJMP $
;
BINBCD:
MOV R3,#BYTES
INC R3
CLR A
RB4:
MOV @R1,A
INC R1
DJNZ R3,RB4
MOV R3,#BYTES
INC R3
RB6:
DEC R1
DJNZ R3,RB6
MOV A,#BYTES
;INC R3
MOV B,#8
MUL AB
MOV R7,A
LOOP:
MOV R3,#BYTES
CLR C
RB1:
MOV A,@R0
RLC A
MOV @R0,A
INC R0
DJNZ R3,RB1
MOV R3,#BYTES
RB3:
DEC R0
DJNZ R3,RB3
MOV R3,#BYTES
INC R3
RB2:
MOV A,@R1
ADDC A,@R1
DA A


MOV @R1,A
INC R1
DJNZ R3,RB2
MOV R3,#BYTES
INC R3
RB5:
DEC R1
DJNZ R3,RB5
DJNZ R7,LOOP
RET

ADDP:
MOV  A,@R0
ADDC A,@R1
DA A
MOV @R0,A
INC R0
INC R1
DJNZ R2,ADDP
RET

END


